# IAR project led.ewp, settings and files
configuration Project (ARM, debug)
  General.OGChipSelectEditMenu: STM32L053R8 ST STM32L053R8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: STM32L053xx
  ICCARM.CCIncludePath2: source; source\Include; source\linker
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: led.hex
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: source\linker\stm32l053xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    source/: startup_stm32l053xx.s
  group User
    ./: main.cpp
    source/: system_stm32l0xx.c
