# IAR project led.ewp, settings and files
configuration led (ARM, debug)
  General.OGChipSelectEditMenu: STM32L053R6 ST STM32L053R6
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L053xx
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32L0xx_HAL_Driver/Inc; ../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32L0xx/Include; ../Drivers/CMSIS/Include; ..\Src\delay; ..\Src\lcd_sym_handler; ../../../../../../../../Inc; ../../../../../../../../Drivers/STM32L0xx_HAL_Driver/Inc; ../../../../../../../../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy; ../../../../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Include; ../../../../../../../../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: led.out
  ILINK.IlinkIcfFile: stm32l053xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l053xx.s
  group Application/User
    ../Src/: main.cc stm32l0xx_hal_msp.c stm32l0xx_it.c
    ../Inc/: main.h
  group Application/User/delay
    ../Src/delay/: delay.c delay.h
  group Application/User/lcd_sym_handler
    ../Src/lcd_sym_handler/: lcd_sym_handler.cc lcd_sym_handler.h
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_lcd.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c
